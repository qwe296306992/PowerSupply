# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\spi_oled;..\User\systick;..\User\fonts;..\User\keys;..\User\encoder;..\User\tim_oled;..\User;..\User\at25;..\User\tim_delay;..\User\tim_cycle;..\User\adc;..\User\usart;..\User\can;..\User\hardware;..\User\dac;..\User\tim_slope;..\User\protect;..\User\softstart;..\User\software;..\User\SCR_Controller;..\User\alternative_SCR_Controller;..\User\WDG;..\User\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/spi_oled/: spi_oled.c
    ../User/systick/: systick.c
    ../User/fonts/: fonts.c
    ../User/keys/: keys.c
    ../User/encoder/: encoder.c
    ../User/tim_oled/: tim_oled.c
    ../User/at25/: at25.c
    ../User/tim_delay/: tim_delay.c
    ../User/tim_cycle/: tim_cycle.c
    ../User/adc/: adc.c
    ../User/dac/: dac.c
    ../User/usart/: usart.c
    ../User/hardware/: hardware.c
    ../User/can/: can.c
    ../User/tim_slope/: tim_slope.c
    ../User/protect/: protect.c
    ../User/softstart/: softstart.c
    ../User/software/: software.c
    ../User/SCR_Controller/: SCR_Controller.c
    ../User/WDG/: wdg.c
    ../User/RTC/: rtc.c
  group DOC
    ../Doc/: readme.txt
